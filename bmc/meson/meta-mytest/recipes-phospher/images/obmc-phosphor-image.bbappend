IMAGE_BASENAME = "obmc-phosphor-image"
DESCRIPTION = "OpenBMC image for Raspberry Pi 3 with Phosphor stack"

IMAGE_INSTALL:append = " hello"